# IAR project bacnet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_XL; USE_STDPERIPH_DRIVER; BACDL_MSTP; MAX_APDU=480; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; WRITE_PROPERTY
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\include; ..\..\demo\object; CMSIS\CM3\CoreSupport; CMSIS\CM3\DeviceSupport\ST\STM32F10x; drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_XL; USE_STDPERIPH_DRIVER; BACDL_MSTP; MAX_APDU=480; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; WRITE_PROPERTY
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: bacnet.out
  ILINK.IlinkIcfFile: D:\code\bacnet-stack\ports\stm32f10x\stm32f10x_flash.icf
  group (top)
    ./: automac.c bacnet.c bo.c device.c dlmstp.c led.c main.c rs485.c stm32f10x_it.c system_stm32f10x.c timer.c timer_sys.c
  group BACnet
    ../../src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c dcc.c fifo.c iam.c ihave.c memcopy.c npdu.c rd.c reject.c ringbuf.c rp.c rpm.c whohas.c whois.c wp.c
  group BACnet-Handlers
    ../../demo/handler/: h_dcc.c h_npdu.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c
  group Cortex-M3
    CMSIS/CM3/CoreSupport/: core_cm3.c
    CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_xl.s
  group STM32-Lib
    drivers/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
