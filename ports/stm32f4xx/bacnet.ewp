# IAR project bacnet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI  ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F4XX; BACDL_MSTP; MAX_APDU=480; BACNET_BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=1; BACAPP_MINIMAL
  ICCARM.CCDiagSuppress: Pe550,Pa084
  ICCARM.CCIncludePath2: $PROJ_DIR$; external\CMSIS; external\CMSIS\iar; external\STM32F4xx_StdPeriph_Driver\\inc; ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bacnet.bin
  ILINK.IlinkOutputFile: bacnet.out
  ILINK.IlinkIcfFile: stm32f4xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group BACnet Core
    ../../src/bacnet/: abort.c bacaction.c bacaddr.c bacapp.c bacdcode.c bacdest.c bacdevobjpropref.c bacerror.c bacint.c bacreal.c bacstr.c cov.c datetime.c dcc.c indtext.c iam.c ihave.c hostnport.c lighting.c memcopy.c npdu.c proplist.c rd.c reject.c rp.c rpm.c shed_level.c timer_value.c timestamp.c timesync.c whohas.c whois.c wp.c
  group BACnet Datalink
    ../../src/bacnet/datalink/: cobs.c crc.c dlmstp.c mstp.c mstptext.c
  group BACnet NPDU Handler
    ../../src/bacnet/basic/npdu/: h_npdu.c
  group BACnet Basic Objects
    ../../src/bacnet/basic/object/: ai.c ao.c av.c bi.c bo.c bv.c ms-input.c mso.c msv.c
  group BACnet Basic Services
    ../../src/bacnet/basic/service/: h_apdu.c h_dcc.c h_noserv.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c s_iam.c s_ihave.c
  group BACnet Basic System
    ../../src/bacnet/basic/program/ubasic/: ubasic.c tokenizer.c
    ../../src/bacnet/basic/sys/: bigend.c debug.c fifo.c keylist.c mstimer.c ringbuf.c
  group BACnet TSM Handler
    ../../src/bacnet/basic/tsm/: tsm.c
  group Hardware
    ./: led.c mstimer-init.c rs485.c stm32f4xx_it.c system_stm32f4xx.c ubasic-port.c
  group NUCLEO-BACnet
    ./: bacnet.c device.c netport.c
  group STM32F4-STARTUP
    external/CMSIS/iar/: startup_stm32f4xx.s
  group STM32F4XX_LIB
    external/STM32F4xx_StdPeriph_Driver//src/: stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_misc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
