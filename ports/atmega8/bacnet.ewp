# IAR project bacnet.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m168 ATmega168
  ICCAVR.CCDefines: BACDL_MSTP; MAX_APDU=50; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; BACAPP_REAL; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; BACAPP_OBJECT_ID; WRITE_PROPERTY
  ICCAVR.CCDiagSuppress: Pe550
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; ..\..\include; ..\..\demo\object
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.GenDeviceSelectMenu: m8 ATmega8
  group (top)
    ./: apdu.c device.c dlmstp.c main.c rs485.c timer.c
  group BACnet-Core
    ../../src/: abort.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c iam.c npdu.c reject.c rp.c whois.c
  group BACnet-Handlers
    ../../demo/handler/: h_npdu.c h_rp.c noserv.c txbuf.c
