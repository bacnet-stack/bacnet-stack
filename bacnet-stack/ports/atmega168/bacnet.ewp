# IAR project bacnet.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0xff
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BACDL_MSTP; MAX_APDU=128; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; BACAPP_REAL
  ICCAVR.CCDiagSuppress: Pe550
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; ..\..\include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ../../src/: abort.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c iam.c npdu.c reject.c rp.c whois.c
    ./: apdu.c av.c avr035.h device.c dlmstp.c h_rp.c h_whois.c hardware.h iar2gcc.h main.c rs485.c rs485.h timer.c timer.h
    ../../demo/handler/: noserv.c txbuf.c
